# IAR project Tx_Module_Manager.ewp, settings and files
configuration Tx_Module_Manager (ARM, debug)
  General.OGChipSelectEditMenu: B-U585I-IOT02A ST B-U585I-IOT02A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: TXM_MODULE_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE=1; USE_HAL_DRIVER; STM32U585xx; FX_FILEX_PRESENT; NX_INCLUDE_USER_DEFINE_FILE; USE_STATIC_ALLOCATION; CRC_EN; AI_NETWORK_LOAD_FROM_FILE; MODULE_LOAD_FROM_FILE
  ICCARM.CCIncludePath2: ../Inc; ../LevelX/Target; ../NetXDuo/Target; ../NetXDuo/App; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Middlewares/ST/filex/ports/cortex_m3/gnu/inc; ../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/iar/inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32U5xx_Nucleo; ../../../../../../Middlewares/ST/threadx/common_modules/inc; ../../../../../../Middlewares/ST/threadx/common_modules/module_manager/inc; ../../../../../../Middlewares/ST/filex/common/inc; ../../../../../../Middlewares/ST/filex/port/generic/inc; ../LevelX/App; ../../../../../../Middlewares/ST/levelx/common/inc; ../../../../../../Middlewares\ST\levelx\target; ../../../../../../Middlewares/ST/netxduo\common\inc; ../../../../../../Middlewares/ST/netxduo/common\drivers\wifi\mxchip; ../../../../../../Drivers/BSP/Components/mx_wifi; ../../../../../../Drivers/BSP/Components/mx_wifi/core; ../../../../../../Drivers/BSP/Components\mx25lm51245g; ../../../../../../Middlewares/ST/netxduo\ports\cortex_m33\iar\inc; ../../../../../../Middlewares/ST/netxduo\addons\dhcp; ../../../../../../Middlewares/ST/netxduo\addons\sntp; ../../../../../../Middlewares/ST/netxduo\addons\dns; ../../../../../../Middlewares/ST/netxduo\addons\ftp; ../../../../../../Middlewares\ST\threadx\common_modules\module_manager\inc; ../../../../../../X-CUBE-AI/App; ../../../../../../Middlewares/ST/AI/Inc; ../../../../../../X-CUBE-AI/Target; ../../../../../../X-CUBE-AI
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_NON_SECURE=1
  OBJCOPY.OOCOutputFile: Tx_Module_Manager.hex
  ILINK.IlinkOutputFile: Tx_Module_Manager.out
  ILINK.IlinkIcfFile: stm32u575xx_flash_module_manager.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: app_AI_reloc_load.c app_filex.c app_threadx.c main.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c tx_initialize_low_level.S
  group Application/User/LevelX/target
    ../LevelX/Target/: lx_stm32_ospi_driver.h lx_stm32_ospi_driver_glue.c
  group Application/User/NetX/App
    ../NetXDuo/App/: app_netxduo.c app_netxduo.h nx_user.h
  group Application/User/NetX/Target
    ../NetXDuo/Target/: mx_wifi_azure_rtos_conf.h
  group Application/User/X-CUBE-AI
    ../../../../../../X-CUBE-AI/App/: ai_reloc_network.c aiSystemPerformance_RELOC.c aiTestHelper.c aiTestUtility.c app_x-cube-ai.c lc_print.c network_img_rel.c
  group Drivers/BSP/Components/mx_wifi
    ../../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/core/: mx_wifi_hci.c mx_wifi_ipc.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
  group Drivers/CMSIS
    ../../../../../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a.c
    ../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_dlyb.c
  group Middlewares/filex/common/driver
    ../../../../../../Middlewares/ST/filex/common/drivers/: fx_stm32_levelx_nor_driver.c fx_stm32_sram_driver.c
  group Middlewares/filex/common/inc
    ../../../../../../Middlewares/ST/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group Middlewares/filex/common/src
    ../../../../../../Middlewares/ST/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_exFAT_entry_read.c fx_directory_exFAT_entry_write.c fx_directory_exFAT_free_search.c fx_directory_exFAT_unicode_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_fault_tolerant_add_bitmap_log.c fx_fault_tolerant_add_checksum_log.c fx_fault_tolerant_add_dir_log.c fx_fault_tolerant_add_FAT_log.c fx_fault_tolerant_apply_logs.c fx_fault_tolerant_calculate_checksum.c fx_fault_tolerant_cleanup_FAT_chain.c fx_fault_tolerant_create_log_file.c fx_fault_tolerant_enable.c fx_fault_tolerant_read_directory_sector.c fx_fault_tolerant_read_FAT.c fx_fault_tolerant_read_log_file.c fx_fault_tolerant_recover.c fx_fault_tolerant_reset_log_file.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_transaction_end.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_transaction_start.c fx_fault_tolerant_write_log_file.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_trace_event_insert.c fx_trace_event_update.c fx_trace_object_register.c fx_trace_object_unregister.c fx_unicode_directory_create.c fx_unicode_directory_entry_change.c fx_unicode_directory_entry_read.c fx_unicode_directory_rename.c fx_unicode_directory_search.c fx_unicode_file_create.c fx_unicode_file_rename.c fx_unicode_length_get.c fx_unicode_length_get_extended.c fx_unicode_name_get.c fx_unicode_name_get_extended.c fx_unicode_short_name_get.c fx_unicode_short_name_get_extended.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c fxe_unicode_directory_create.c fxe_unicode_directory_rename.c fxe_unicode_file_create.c fxe_unicode_file_rename.c fxe_unicode_name_get.c fxe_unicode_name_get_extended.c fxe_unicode_short_name_get.c fxe_unicode_short_name_get_extended.c
  group Middlewares/filex/port/generic/inc
    ../../../../../../Middlewares/ST/filex/ports/generic/inc/: fx_port.h
  group Middlewares/levelx/NOR_Flash_Support
    ../../../../../../Middlewares/ST/levelx/common/src/: lx_nor_flash_block_reclaim.c lx_nor_flash_close.c lx_nor_flash_defragment.c lx_nor_flash_driver_block_erase.c lx_nor_flash_driver_read.c lx_nor_flash_driver_write.c lx_nor_flash_extended_cache_enable.c lx_nor_flash_initialize.c lx_nor_flash_logical_sector_find.c lx_nor_flash_next_block_to_erase_find.c lx_nor_flash_open.c lx_nor_flash_partial_defragment.c lx_nor_flash_physical_sector_allocate.c lx_nor_flash_sector_mapping_cache_invalidate.c lx_nor_flash_sector_read.c lx_nor_flash_sector_release.c lx_nor_flash_sector_write.c lx_nor_flash_simulator.c lx_nor_flash_system_error.c
  group Middlewares/levelx/OctoSPI_memory_interface
    ../../../../../../Middlewares/ST/levelx/common/drivers/: lx_stm32_ospi_driver.c
  group Middlewares/netxduo/addons/dhcp
    ../../../../../../Middlewares/ST/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcp_client.h
  group Middlewares/netxduo/addons/dns
    ../../../../../../Middlewares/ST/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group Middlewares/netxduo/addons/ftp
    ../../../../../../Middlewares/ST/netxduo/addons/ftp/: nxd_ftp_client.c nxd_ftp_client.h
  group Middlewares/netxduo/addons/sntp
    ../../../../../../Middlewares/ST/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group Middlewares/netxduo/common/driver/wifi/mxchip
    ../../../../../../Middlewares/ST/netxduo/common/drivers/wifi/mxchip/: mx_wifi_azure_rtos.c nx_driver_emw3080.c
  group Middlewares/netxduo/common/src
    ../../../../../../Middlewares/ST/netxduo/common/src/: nx_arp_announce_send.c nx_arp_dynamic_entries_invalidate.c nx_arp_dynamic_entry_delete.c nx_arp_dynamic_entry_set.c nx_arp_enable.c nx_arp_entry_allocate.c nx_arp_entry_delete.c nx_arp_gratuitous_send.c nx_arp_hardware_address_find.c nx_arp_info_get.c nx_arp_initialize.c nx_arp_interface_entries_delete.c nx_arp_ip_address_find.c nx_arp_packet_deferred_receive.c nx_arp_packet_receive.c nx_arp_packet_send.c nx_arp_periodic_update.c nx_arp_probe_send.c nx_arp_queue_process.c nx_arp_queue_send.c nx_arp_static_entries_delete.c nx_arp_static_entry_create.c nx_arp_static_entry_delete.c nx_arp_static_entry_delete_internal.c nx_icmp_cleanup.c nx_icmp_enable.c nx_icmp_info_get.c nx_icmp_interface_ping.c nx_icmp_interface_ping6.c nx_icmp_packet_process.c nx_icmp_packet_receive.c nx_icmp_ping.c nx_icmp_ping6.c nx_icmp_queue_process.c nx_icmpv4_packet_process.c nx_icmpv4_process_echo_reply.c nx_icmpv4_process_echo_request.c nx_icmpv4_send_error_message.c nx_icmpv6_DAD_clear_NDCache_entry.c nx_icmpv6_DAD_failure.c nx_icmpv6_dest_table_add.c nx_icmpv6_dest_table_find.c nx_icmpv6_destination_table_periodic_update.c nx_icmpv6_packet_process.c nx_icmpv6_perform_DAD.c nx_icmpv6_process_echo_reply.c nx_icmpv6_process_echo_request.c nx_icmpv6_process_na.c nx_icmpv6_process_ns.c nx_icmpv6_process_packet_too_big.c nx_icmpv6_process_ra.c nx_icmpv6_process_redirect.c nx_icmpv6_send_error_message.c nx_icmpv6_send_ns.c nx_icmpv6_send_queued_packets.c nx_icmpv6_send_rs.c nx_icmpv6_validate_neighbor_message.c nx_icmpv6_validate_options.c nx_icmpv6_validate_ra.c nx_igmp_enable.c nx_igmp_info_get.c nx_igmp_interface_report_send.c nx_igmp_loopback_disable.c nx_igmp_loopback_enable.c nx_igmp_multicast_check.c nx_igmp_multicast_interface_join.c nx_igmp_multicast_interface_join_internal.c nx_igmp_multicast_interface_leave.c nx_igmp_multicast_interface_leave_internal.c nx_igmp_multicast_join.c nx_igmp_multicast_leave.c nx_igmp_packet_process.c nx_igmp_packet_receive.c nx_igmp_periodic_processing.c nx_igmp_queue_process.c nx_invalidate_destination_entry.c nx_ip_address_change_notify.c nx_ip_address_get.c nx_ip_address_set.c nx_ip_auxiliary_packet_pool_set.c nx_ip_checksum_compute.c nx_ip_create.c nx_ip_deferred_link_status_process.c nx_ip_delete.c nx_ip_delete_queue_clear.c nx_ip_dispatch_process.c nx_ip_driver_deferred_enable.c nx_ip_driver_deferred_processing.c nx_ip_driver_deferred_receive.c nx_ip_driver_direct_command.c nx_ip_driver_interface_direct_command.c nx_ip_driver_link_status_event.c nx_ip_driver_packet_send.c nx_ip_fast_periodic_timer_entry.c nx_ip_forward_packet_process.c nx_ip_forwarding_disable.c nx_ip_forwarding_enable.c nx_ip_fragment_assembly.c nx_ip_fragment_disable.c nx_ip_fragment_enable.c nx_ip_fragment_forward_packet.c nx_ip_fragment_packet.c nx_ip_fragment_timeout_check.c nx_ip_gateway_address_clear.c nx_ip_gateway_address_get.c nx_ip_gateway_address_set.c nx_ip_header_add.c nx_ip_info_get.c nx_ip_initialize.c nx_ip_interface_address_get.c nx_ip_interface_address_mapping_configure.c nx_ip_interface_address_set.c nx_ip_interface_attach.c nx_ip_interface_capability_get.c nx_ip_interface_capability_set.c nx_ip_interface_detach.c nx_ip_interface_info_get.c nx_ip_interface_mtu_set.c nx_ip_interface_physical_address_get.c nx_ip_interface_physical_address_set.c nx_ip_interface_status_check.c nx_ip_link_status_change_notify_set.c nx_ip_max_payload_size_find.c nx_ip_packet_checksum_compute.c nx_ip_packet_deferred_receive.c nx_ip_packet_receive.c nx_ip_packet_send.c nx_ip_periodic_timer_entry.c nx_ip_raw_packet_cleanup.c nx_ip_raw_packet_disable.c nx_ip_raw_packet_enable.c nx_ip_raw_packet_filter_set.c nx_ip_raw_packet_processing.c nx_ip_raw_packet_receive.c nx_ip_raw_packet_send.c nx_ip_raw_packet_source_send.c nx_ip_raw_receive_queue_max_set.c nx_ip_route_find.c nx_ip_static_route_add.c nx_ip_static_route_delete.c nx_ip_status_check.c nx_ip_thread_entry.c nx_ipv4_multicast_interface_join.c nx_ipv4_multicast_interface_leave.c nx_ipv4_option_process.c nx_ipv4_packet_receive.c nx_ipv6_fragment_process.c nx_ipv6_header_add.c nx_ipv6_multicast_join.c nx_ipv6_multicast_leave.c nx_ipv6_option_error.c nx_ipv6_packet_copy.c nx_ipv6_packet_receive.c nx_ipv6_packet_send.c nx_ipv6_prefix_list_add_entry.c nx_ipv6_prefix_list_delete.c nx_ipv6_prefix_list_delete_entry.c nx_ipv6_process_fragment_option.c nx_ipv6_process_hop_by_hop_option.c nx_ipv6_process_routing_option.c nx_ipv6_util.c nx_md5.c nx_nd_cache_add.c nx_nd_cache_add_entry.c nx_nd_cache_delete_internal.c nx_nd_cache_fast_periodic_update.c nx_nd_cache_find_entry.c nx_nd_cache_find_entry_by_mac_addr.c nx_nd_cache_interface_entries_delete.c nx_nd_cache_slow_periodic_update.c nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_ram_network_driver.c nx_rarp_disable.c nx_rarp_enable.c nx_rarp_info_get.c nx_rarp_packet_deferred_receive.c nx_rarp_packet_receive.c nx_rarp_packet_send.c nx_rarp_periodic_update.c nx_rarp_queue_process.c nx_system_initialize.c nx_tcp_cleanup_deferred.c nx_tcp_client_bind_cleanup.c nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_port_get.c nx_tcp_client_socket_unbind.c nx_tcp_connect_cleanup.c nx_tcp_deferred_cleanup_check.c nx_tcp_disconnect_cleanup.c nx_tcp_enable.c nx_tcp_fast_periodic_processing.c nx_tcp_free_port_find.c nx_tcp_info_get.c nx_tcp_initialize.c nx_tcp_mss_option_get.c nx_tcp_no_connection_reset.c nx_tcp_packet_process.c nx_tcp_packet_receive.c nx_tcp_packet_send_ack.c nx_tcp_packet_send_control.c nx_tcp_packet_send_fin.c nx_tcp_packet_send_probe.c nx_tcp_packet_send_rst.c nx_tcp_packet_send_syn.c nx_tcp_periodic_processing.c nx_tcp_queue_process.c nx_tcp_receive_cleanup.c nx_tcp_server_socket_accept.c nx_tcp_server_socket_driver_listen.c nx_tcp_server_socket_listen.c nx_tcp_server_socket_relisten.c nx_tcp_server_socket_unaccept.c nx_tcp_server_socket_unlisten.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_bytes_available.c nx_tcp_socket_connection_reset.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_disconnect_complete_notify.c nx_tcp_socket_driver_establish.c nx_tcp_socket_driver_packet_receive.c nx_tcp_socket_establish_notify.c nx_tcp_socket_info_get.c nx_tcp_socket_mss_get.c nx_tcp_socket_mss_peer_get.c nx_tcp_socket_mss_set.c nx_tcp_socket_packet_process.c nx_tcp_socket_peer_info_get.c nx_tcp_socket_queue_depth_notify_set.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_receive_queue_flush.c nx_tcp_socket_receive_queue_max_set.c nx_tcp_socket_retransmit.c nx_tcp_socket_send.c nx_tcp_socket_send_internal.c nx_tcp_socket_state_ack_check.c nx_tcp_socket_state_closing.c nx_tcp_socket_state_data_check.c nx_tcp_socket_state_established.c nx_tcp_socket_state_fin_wait1.c nx_tcp_socket_state_fin_wait2.c nx_tcp_socket_state_last_ack.c nx_tcp_socket_state_syn_received.c nx_tcp_socket_state_syn_sent.c nx_tcp_socket_state_transmit_check.c nx_tcp_socket_state_wait.c nx_tcp_socket_thread_resume.c nx_tcp_socket_thread_suspend.c nx_tcp_socket_timed_wait_callback.c nx_tcp_socket_transmit_configure.c nx_tcp_socket_transmit_queue_flush.c nx_tcp_socket_window_update_notify_set.c nx_tcp_transmit_cleanup.c nx_tcp_window_scaling_option_get.c nx_trace_event_insert.c nx_trace_event_update.c nx_trace_object_register.c nx_trace_object_unregister.c nx_udp_bind_cleanup.c nx_udp_enable.c nx_udp_free_port_find.c nx_udp_info_get.c nx_udp_packet_info_extract.c nx_udp_packet_receive.c nx_udp_receive_cleanup.c nx_udp_socket_bind.c nx_udp_socket_bytes_available.c nx_udp_socket_checksum_disable.c nx_udp_socket_checksum_enable.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_driver_packet_receive.c nx_udp_socket_info_get.c nx_udp_socket_port_get.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_source_send.c nx_udp_socket_unbind.c nx_udp_source_extract.c nx_utility.c nxd_icmp_enable.c nxd_icmp_ping.c nxd_icmp_source_ping.c nxd_icmpv6_ra_flag_callback_set.c nxd_ip_raw_packet_send.c nxd_ip_raw_packet_source_send.c nxd_ipv6_address_change_notify.c nxd_ipv6_address_delete.c nxd_ipv6_address_get.c nxd_ipv6_address_set.c nxd_ipv6_default_router_add.c nxd_ipv6_default_router_add_internal.c nxd_ipv6_default_router_delete.c nxd_ipv6_default_router_entry_get.c nxd_ipv6_default_router_get.c nxd_ipv6_default_router_number_of_entries_get.c nxd_ipv6_default_router_table_init.c nxd_ipv6_destination_table_find_next_hop.c nxd_ipv6_disable.c nxd_ipv6_enable.c nxd_ipv6_find_default_router_from_address.c nxd_ipv6_find_max_prefix_length.c nxd_ipv6_interface_find.c nxd_ipv6_multicast_interface_join.c nxd_ipv6_multicast_interface_leave.c nxd_ipv6_prefix_router_timer_tick.c nxd_ipv6_raw_packet_send_internal.c nxd_ipv6_router_lookup.c nxd_ipv6_router_solicitation_check.c nxd_ipv6_search_onlink.c nxd_ipv6_stateless_address_autoconfig_disable.c nxd_ipv6_stateless_address_autoconfig_enable.c nxd_nd_cache_entry_delete.c nxd_nd_cache_entry_set.c nxd_nd_cache_hardware_address_find.c nxd_nd_cache_invalidate.c nxd_nd_cache_ip_address_find.c nxd_tcp_client_socket_connect.c nxd_tcp_socket_peer_info_get.c nxd_udp_packet_info_extract.c nxd_udp_socket_send.c nxd_udp_socket_source_send.c nxd_udp_source_extract.c nxde_icmp_enable.c nxde_icmp_ping.c nxde_icmp_source_ping.c nxde_icmpv6_ra_flag_callback_set.c nxde_ip_raw_packet_send.c nxde_ip_raw_packet_source_send.c nxde_ipv6_address_change_notify.c nxde_ipv6_address_delete.c nxde_ipv6_address_get.c nxde_ipv6_address_set.c nxde_ipv6_default_router_add.c nxde_ipv6_default_router_delete.c nxde_ipv6_default_router_entry_get.c nxde_ipv6_default_router_get.c nxde_ipv6_default_router_number_of_entries_get.c nxde_ipv6_disable.c nxde_ipv6_enable.c nxde_ipv6_multicast_interface_join.c nxde_ipv6_multicast_interface_leave.c nxde_ipv6_stateless_address_autoconfig_disable.c nxde_ipv6_stateless_address_autoconfig_enable.c nxde_nd_cache_entry_delete.c nxde_nd_cache_entry_set.c nxde_nd_cache_hardware_address_find.c nxde_nd_cache_invalidate.c nxde_nd_cache_ip_address_find.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_packet_info_extract.c nxde_udp_socket_send.c nxde_udp_socket_source_send.c nxde_udp_source_extract.c nxe_arp_dynamic_entries_invalidate.c nxe_arp_dynamic_entry_set.c nxe_arp_enable.c nxe_arp_entry_delete.c nxe_arp_gratuitous_send.c nxe_arp_hardware_address_find.c nxe_arp_info_get.c nxe_arp_ip_address_find.c nxe_arp_static_entries_delete.c nxe_arp_static_entry_create.c nxe_arp_static_entry_delete.c nxe_icmp_enable.c nxe_icmp_info_get.c nxe_icmp_ping.c nxe_igmp_enable.c nxe_igmp_info_get.c nxe_igmp_loopback_disable.c nxe_igmp_loopback_enable.c nxe_igmp_multicast_interface_join.c nxe_igmp_multicast_interface_leave.c nxe_igmp_multicast_join.c nxe_igmp_multicast_leave.c nxe_ip_address_change_notify.c nxe_ip_address_get.c nxe_ip_address_set.c nxe_ip_auxiliary_packet_pool_set.c nxe_ip_create.c nxe_ip_delete.c nxe_ip_driver_direct_command.c nxe_ip_driver_interface_direct_command.c nxe_ip_forwarding_disable.c nxe_ip_forwarding_enable.c nxe_ip_fragment_disable.c nxe_ip_fragment_enable.c nxe_ip_gateway_address_clear.c nxe_ip_gateway_address_get.c nxe_ip_gateway_address_set.c nxe_ip_info_get.c nxe_ip_interface_address_get.c nxe_ip_interface_address_mapping_configure.c nxe_ip_interface_address_set.c nxe_ip_interface_attach.c nxe_ip_interface_capability_get.c nxe_ip_interface_capability_set.c nxe_ip_interface_detach.c nxe_ip_interface_info_get.c nxe_ip_interface_mtu_set.c nxe_ip_interface_physical_address_get.c nxe_ip_interface_physical_address_set.c nxe_ip_interface_status_check.c nxe_ip_link_status_change_notify_set.c nxe_ip_max_payload_size_find.c nxe_ip_raw_packet_disable.c nxe_ip_raw_packet_enable.c nxe_ip_raw_packet_filter_set.c nxe_ip_raw_packet_receive.c nxe_ip_raw_packet_send.c nxe_ip_raw_packet_source_send.c nxe_ip_raw_receive_queue_max_set.c nxe_ip_static_route_add.c nxe_ip_static_route_delete.c nxe_ip_status_check.c nxe_ipv4_multicast_interface_join.c nxe_ipv4_multicast_interface_leave.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_rarp_disable.c nxe_rarp_enable.c nxe_rarp_info_get.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_port_get.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_free_port_find.c nxe_tcp_info_get.c nxe_tcp_server_socket_accept.c nxe_tcp_server_socket_listen.c nxe_tcp_server_socket_relisten.c nxe_tcp_server_socket_unaccept.c nxe_tcp_server_socket_unlisten.c nxe_tcp_socket_bytes_available.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_disconnect_complete_notify.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_info_get.c nxe_tcp_socket_mss_get.c nxe_tcp_socket_mss_peer_get.c nxe_tcp_socket_mss_set.c nxe_tcp_socket_peer_info_get.c nxe_tcp_socket_queue_depth_notify_set.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_receive_queue_max_set.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_tcp_socket_timed_wait_callback.c nxe_tcp_socket_transmit_configure.c nxe_tcp_socket_window_update_notify_set.c nxe_udp_enable.c nxe_udp_free_port_find.c nxe_udp_info_get.c nxe_udp_packet_info_extract.c nxe_udp_socket_bind.c nxe_udp_socket_bytes_available.c nxe_udp_socket_checksum_disable.c nxe_udp_socket_checksum_enable.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_info_get.c nxe_udp_socket_port_get.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_source_send.c nxe_udp_socket_unbind.c nxe_udp_source_extract.c
  group Middlewares/ThreadX/Core
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_iar.c tx_timer_interrupt.s
  group Middlewares/ThreadX/Module_Manager
    ../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/iar/module_manager/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_stack_build.s tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_return.s txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c txm_module_manager_alignment_adjust.c txm_module_manager_external_memory_enable.c txm_module_manager_memory_fault_handler.c txm_module_manager_memory_fault_notify.c txm_module_manager_mm_register_setup.c txm_module_manager_port_dispatch.c txm_module_manager_thread_stack_build.s
    ../../../../../../Middlewares/ST/threadx/common_modules/module_manager/src/: txm_module_manager_absolute_load.c txm_module_manager_application_request.c txm_module_manager_callback_request.c txm_module_manager_event_flags_notify_trampoline.c txm_module_manager_file_load.c txm_module_manager_in_place_load.c txm_module_manager_initialize.c txm_module_manager_internal_load.c txm_module_manager_kernel_dispatch.c txm_module_manager_maximum_module_priority_set.c txm_module_manager_memory_load.c txm_module_manager_object_allocate.c txm_module_manager_object_deallocate.c txm_module_manager_object_pointer_get.c txm_module_manager_object_pointer_get_extended.c txm_module_manager_object_pool_create.c txm_module_manager_properties_get.c txm_module_manager_queue_notify_trampoline.c txm_module_manager_semaphore_notify_trampoline.c txm_module_manager_start.c txm_module_manager_stop.c txm_module_manager_thread_create.c txm_module_manager_thread_notify_trampoline.c txm_module_manager_thread_reset.c txm_module_manager_timer_notify_trampoline.c txm_module_manager_unload.c txm_module_manager_util.c
